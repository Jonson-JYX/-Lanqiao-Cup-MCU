# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LED_Display.c LED.c DS18B20.c KEY.c PCF8591.c Delay.c IIC.c OneWire.c Common.h LED_Display.h LED.h DS18B20.h KEY.h PCF8591.h Delay.h IIC.h OneWire.h
