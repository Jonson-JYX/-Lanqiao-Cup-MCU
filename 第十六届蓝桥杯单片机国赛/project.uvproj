# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Sound.c DS18B20.c NE555.c Uart.c DS1302.c KEY.c Relay.c LED.c PCF8591.c LED_Display.c Onewire.c IIC.c Timer.c Delay.c Sound.h DS1302.h NE555.h Uart.h DS18B20.h KEY.h Relay.h LED.h PCF8591.h LED_Display.h Onewire.h IIC.h Timer.h Delay.h Common.h Tank.c Tank.h
