# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c KEY.c PCF8591.c LED.c Uart.c LED_Display.c Delay.c IIC.c Timer.c Common.h KEY.h PCF8591.h LED.h Uart.h LED_Display.h Delay.h IIC.h Timer.h
