# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c DS18B20.c LED.c LED_Display.c Delay.c KEY.c Timer.c Onewire.c Common.h DS1302.h DS18B20.h LED.h LED_Display.h Delay.h KEY.h Timer.h Onewire.h
