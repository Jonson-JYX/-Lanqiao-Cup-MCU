# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LED_Diplay.c DS1302.c DS18B20.c PCF8591.c Onewire.c IIC.c Delay.c KEY.c Common.h LED_Display.h DS1302.h DS18B20.h PCF8591.h Onewire.h IIC.h Delay.h KEY.h
