# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c NE555.c KEY.c DS1302.c PCF8591.c LED.c LED_Display.c Timer.c IIC.c Delay.c Common.h NE555.h KEY.h DS1302.h PCF8591.h LED.h LED_Display.h Timer.h IIC.h Delay.h
