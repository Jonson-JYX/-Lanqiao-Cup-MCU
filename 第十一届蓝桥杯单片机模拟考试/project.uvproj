# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c KEY.c EEPROM.c LED.c Relay.c LED_Display.c IIC.c Delay.c Timer.c Common.h KEY.h EEPROM.h LED.h Relay.h LED_Display.h IIC.h Delay.h Timer.h
