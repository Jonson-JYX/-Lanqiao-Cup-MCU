# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c PCF8591.c NE555.c KEY.c DS1302.c DS18B20.c LED.c LED_Display.c IIC.c Onewire.c Timer.c Delay.c Common.h PCF8591.h NE555.h KEY.h DS1302.h DS18B20.h LED.h LED_Display.h IIC.h Onewire.h Timer.h Delay.h
