# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Sound.c PCF8591.c IIC.c DS18B20.c KEY.c Relay.c LED.c LED_Display.c Onewire.c Delay.c Timer.c Common.h Sound.h PCF8591.h IIC.h DS18B20.h KEY.h Relay.h LED.h LED_Display.h Onewire.h Delay.h Timer.h
