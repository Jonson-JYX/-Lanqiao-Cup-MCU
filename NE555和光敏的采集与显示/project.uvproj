# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c PCF8591.c IIC.c Delay.c LED.c LED_Display.c KEY.c Timer.c NE555.c Common.h PCF8591.h IIC.h Delay.h LED.h LED_Display.h KEY.h Timer.h NE555.h
