# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c KEY.c DS18B20.c PCF8591.c Relay.c Uart.c LED.c LED_Display.c Timer.c IIC.c Delay.c Onewire.c Common.h KEY.h DS18B20.h PCF8591.h Relay.h Uart.h LED.h LED_Display.h Timer.h IIC.h Delay.h Onewire.h
